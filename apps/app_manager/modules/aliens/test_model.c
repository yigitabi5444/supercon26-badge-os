// Differential checks use verbatim original tick code generated by run_model_tests.py.
#include <assert.h>
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include "game.h"
static uint32_t rng;
static uint32_t random_word(void *context) { (void)context; return rng=rng*1664525u+1013904223u; }
static uint32_t esp_random(void) { return random_word(NULL); }
#include "reference.h"
static aliens_game_t port;
static unsigned checks;
static void same(void) { assert(sizeof port==sizeof g); assert(!memcmp(&port,&g,sizeof g)); }
static void reset(void) {
    memset(&g,0,sizeof g); aliens_fill(&port,0,sizeof port);
    g.lives=port.lives=3;g.px=port.px=(W-GW)/2;
    new_wave();aliens_new_wave(&port);same();
}
static void advance(int fire,int move) {
    uint32_t initial=rng;aliens_tick(&port,fire,move,random_word,NULL);uint32_t expected=rng;
    rng=initial;tick(fire,move);assert(rng==expected);same();checks++;
}
static void copy_case(void) { memcpy(&port,&g,sizeof g); }
int main(void) {
    uint32_t controls=42;rng=19;
    for(int game=0;game<64;game++) {
        reset();
        for(int t=0;t<1200&&!g.over;t++) {
            controls=controls*1103515245u+12345u;
            advance((controls>>3)&1, ((int)(controls%3)-1)*GUN_V);
        }
    }
    reset();g.px=1;copy_case();advance(0,-GUN_V);assert(g.px==0);
    g.px=W-GW-1;copy_case();advance(0,GUN_V);assert(g.px==W-GW);
    reset();memset(g.alive,0,sizeof g.alive);copy_case();advance(0,0);assert(g.wave==2&&g.alive[0]);
    reset();memset(g.alive,0,sizeof g.alive);g.boom[0]=BOOM_TICKS;copy_case();
    for(int i=0;i<BOOM_TICKS;i++)advance(0,0);assert(g.wave==2);
    reset();g.dead=1;g.lives=0;copy_case();advance(1,100);assert(g.over);
    reset();g.fx=W+100;g.fy=PY;copy_case();advance(0,0);assert(!g.lives&&g.dead==DEAD_TICKS);
    reset();g.bx[0]=g.px+10;g.by[0]=PY+16-BOMB_V;copy_case();advance(0,0);assert(g.lives==2&&g.dead==DEAD_TICKS);
    reset();g.march_ms=1000;g.sx=g.fx+AW/2;g.sy=g.fy+20+SHOT_V;copy_case();advance(0,0);assert(g.score==30&&!g.alive[0]);
    printf("PASS: %u differential ticks against unchanged built-in source; movement/clamps/shooting/hits/death/wave/invasion; model state %zu bytes\n",checks,sizeof port);
}
